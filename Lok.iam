# Autodesk Inventor assembly: Lok
## iProperties
Created: 2007-03
Part Number: Lok
Document SubType Name: Assembly
Designer: Benno
Manufacturer: Standard
Standards Organization: Custom
Author: Benno
